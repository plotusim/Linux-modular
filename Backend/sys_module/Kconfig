## Backend/sys_module/Kconfig
```kconfig
config SYS_MODULE
    tristate "system call module"
    default m
    help
    some system call module
```
